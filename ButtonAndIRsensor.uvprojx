# Keil uVision project ButtonAndIRsensor.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c GPIO.c GPIO.h GPIO_config.c GPIO_config.h GPIO_reg.h lstd.h GPTM.C GPTM.h GPTM_config.c GPTM_config.h GPTM_reg.h NVIC.c NVIC.h NVIC_config.h NVIC_reg.h SystemControl.c SystemControl.h SystemControl_Config.c SystemControl_config.h SystemControl_reg.h UART.c UART.h UART_config.c UART_config.h UART_reg.h Button.c Button.h HC-05.c HC-05.h InfraredSensor.c InfraredSensor.h DMA.c DMA.h DMA_config.c DMA_config.h DMA_reg.h Switch.c Switch.h Dc_motor.c Dc_motor.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
